FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0003-Header-definitions-need-to-be-external-when-building.patch \
"
