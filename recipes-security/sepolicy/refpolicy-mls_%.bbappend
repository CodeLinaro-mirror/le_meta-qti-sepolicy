SRCREV_refpolicy := "RELEASE_2_20161023"
SRCREV_refpolicy-contrib = "RELEASE_2_20161023"

require refpolicy-qti-common.inc
