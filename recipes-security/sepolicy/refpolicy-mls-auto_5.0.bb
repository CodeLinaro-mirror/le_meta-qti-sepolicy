require refpolicy-qti-common.inc

EXTRA_OEMAKE:append = "CHECKPOLICY='checkpolicy -c 31'"
